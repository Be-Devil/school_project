# Keil uVision project TEST.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.4.2.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: TEST +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\BH1750;..\HARDWARE\DJQD;..\HARDWARE\INIT;..\HARDWARE\CSB;..\HARDWARE\HW;..\HARDWARE\XJ;..\HARDWARE\74HC595;..\USER;..\HARDWARE\EXIT;..\HARDWARE\CAN;..\HARDWARE\CAN_HOST;..\HARDWARE\FIFO;..\stdperiph_lib\inc;..\CMSIS;..\my_lib;..\stdperiph_lib\inc;..\startup;..\HARDWARE\ADC;..\HARDWARE\TIMER;..\HARDWARE\HMC5883L;..\HARDWARE\IIC;..\HARDWARE\SYN7318;..\MYCODE\move;..\MYCODE\feedback;..\MYCODE\RFID;..\MYCODE\code;..\SYSTEM\delay\delay;..\HARDWARE\HTXJ;..\MYCODE\other;..\MYCODE\zigbee;..\MYCODE\infrared
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
    ../CMSIS/startup/arm/: startup_stm32f10x_hd.s
    ../startup/: stm32f10x_it.c
  group USER
    ./: test.c data_channel.c
  group SYS
    ../SYSTEM/delay/: delay_drv.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/delay/delay/: delay.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/INIT/: init.c
    ../HARDWARE/DJQD/: djqd.c
    ../HARDWARE/BH1750/: bh1750.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/XJ/: xj.c
    ../HARDWARE/CSB/: csb.c
    ../HARDWARE/HW/: hw.c
    ../HARDWARE/EXIT/: exit.c
    ./: uart_my.c
    ../HARDWARE/CAN/: can_drv.c
    ../HARDWARE/CAN_HOST/: CanP_HostCom.c
    ../HARDWARE/FIFO/: fifo_drv.c
    ../HARDWARE/ADC/: adc.c power_check.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/SYN7318/: SYN7318.c
    ../HARDWARE/HTXJ/: htxj.c
  group stdperiph_lib
    ../stdperiph_lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group my_lib
    ../my_lib/: my_lib.c
  group readme
    ./: nvic.txt 函数使用说明简介.txt 03词典-用户1.txt
  group MYCODE
    ../MYCODE/move/: move.c
    ../MYCODE/feedback/: feedback.c
    ../MYCODE/RFID/: rc522_my.c RC522.c
    ../MYCODE/code/: code.c
    ../MYCODE/zigbee/: zigbee.c
    ../MYCODE/infrared/: infrared.c
    ../MYCODE/other/: other.c
software components: CMSIS:CORE 4.3.0
